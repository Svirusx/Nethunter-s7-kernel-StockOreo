## drivers/net/wireless/rtl8812au/Kconfig
```kconfig
config 88XXAU
	tristate "Realtek 88xxAU USB WiFi"
	depends on USB
	default y
	---help---
	  Help message of 88XXau
```
